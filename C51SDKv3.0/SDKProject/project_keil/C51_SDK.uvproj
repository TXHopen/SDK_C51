# Keil uVision project C51_SDK.uvproj, settings and files
target c51sdk (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: CC1101_Demo_Slave +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\HW_Config;..\..\HW_Driver\driver_header;..\..\HW_Driver;..\..\SDKProject;..\..\SW_Support;..\..\SW_Support\header;..\..\usercode
  group user_code
    ../../usercode/: user_main.c user_config_prj.h
  group sw_support
    ../../SW_Support/: sw_Gdelay.c sw_SoftTimer.c sw_GCapture.c
  group hw_config
    ../../HW_Config/: hw_config.c hw_Gtimer.c hw_UART.c hw_Timer0.c hw_Timer1.c hw_Timer2.c hw_MEMPool.c hw_ioctrl.c
  group hw_driver
    ../../HW_Driver/: ad0809.c ad9850.c independent_key_4.c LCD1602.c max263.c MAX541x.c pwm.c PWMGroup.c dht11.c ds18b20.c ds1302.c esp8266.c iic.c at24c02.c DigitalTube6.c ad5320.c max1241.c hx711.c lcd12864.c hcsr04.c drv_CC1101.c drv_spi.c drv_button.c
  group SDKMain
    ../: main.c
  group STARTUP
    ./: STARTUP.A51
